# IAR project start-stop.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H743xx; USE_HAL_DRIVER; USE_STM32H7XX_NUCLEO_144
  ICCARM.CCDiagSuppress: Pe540
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\freertos; ..\..\..\..\..\3rd_party\FreeRTOS\Source\include; ..\..\..\..\..\3rd_party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\nucleo-h743zi; ..\..\..\..\..\3rd_party\nucleo-h743zi\Drivers\BSP\STM32H7xx_Nucleo_144; ..\..\..\..\..\3rd_party\nucleo-h743zi\Drivers\STM32H7xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: start-stop.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: start-stop.out
  ILINK.IlinkIcfFile: start-stop.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; STM32H743xx; USE_HAL_DRIVER; USE_STM32H7XX_NUCLEO_144
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: Q_SPY; STM32H743xx; USE_HAL_DRIVER; USE_STM32H7XX_NUCLEO_144
  ICCARM.CCOptLevel: 1
  group Application
    ../: bsp.cpp bsp.h FreeRTOSConfig.h launcher.cpp main.cpp worker.cpp worker.h
  group FreeRTOS
    ../../../../../3rd_party/FreeRTOS/Source/: list.c tasks.c
    ../../../../../3rd_party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s portmacro.h
  group nucleo-h743zi
    ../../../../../3rd_party/nucleo-h743zi/iar/: startup_stm32h743xx.s
    ../../../../../3rd_party/nucleo-h743zi/: stm32h743xx.h stm32h7xx.h stm32h7xx_hal_conf.h stm32h7xx_it.h system_stm32h7xx.c system_stm32h7xx.h
    ../: stm32h7xx_hal_conf.h stm32h7xx_hal_msp.c
    ../../../../../3rd_party/nucleo-h743zi/Drivers/BSP/STM32H7xx_Nucleo_144/: stm32h7xx_nucleo_144.c stm32h7xx_nucleo_144.h
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../include/: qstamp.cpp
  group QP_port
    ../../../../../ports/freertos/: qep_port.h qf_port.cpp qf_port.h qs_port.h
  group QS
    ../../../../../src/qs/: qs.cpp qs_64bit.cpp qs_fp.cpp qs_rx.cpp qutest.cpp
  group STM32H7xx_HAL_Driver
    ../../../../../3rd_party/nucleo-h743zi/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c
