# IAR project blinky-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMS570LS1224PGE TexasInstruments TMS570LS1224PGE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 42
  General.FPU2: 3
  ICCARM.CCDefines: QP_API_VERSION=660
  ICCARM.CCDiagSuppress: Pe540
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\arm-cr\qk\iar; ..\..\..\..\..\3rd_party\launchxl2-tms57012\iar\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: blinky-qk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: blinky-qk.out
  ILINK.IlinkIcfFile: blinky-qk.icf
  ILINK.IlinkProgramEntryLabel: _c_int00
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; QP_API_VERSION=660
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; QP_API_VERSION=660
  ICCARM.CCOptLevel: 1
  group Application
    ../../: blinky.cpp blinky.h bsp.h main.cpp
    ../: bsp.cpp
    ../../../../../include/: qstamp.cpp
  group launchxl2-tms57012
    ../../../../../3rd_party/launchxl2-tms57012/iar/source/: dabort.asm esm.c exceptions.c gio.c het.c notification.c pinmux.c rti.c sci.c sys_core.asm sys_intvecs.asm sys_mpu.asm sys_pcr.c sys_phantom.c sys_pmm.c sys_pmu.asm sys_selftest.c sys_startup.c sys_vim.c system.c
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/: qf_pkg.h qk_pkg.h
    ../../../../../src/qk/: qk.cpp
  group QP_port
    ../../../../../ports/arm-cr/qk/iar/: qep_port.h qf_port.h qk_port.h qs_port.h
  group QS
    ../../../../../src/qs/: qs.cpp qs_fp.cpp qs_rx.cpp
    ../../../../../src/: qs_pkg.h
