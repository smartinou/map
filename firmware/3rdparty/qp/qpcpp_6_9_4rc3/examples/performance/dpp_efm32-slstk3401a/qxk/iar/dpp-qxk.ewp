# IAR project dpp-qxk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: EFM32PG1B200F256GM48
  ICCARM.CCDiagSuppress: Pe540
  ICCARM.IExtraOptions: --enable-restrict
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\arm-cm\qxk\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\efm32pg1b
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qxk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp-qxk.out
  ILINK.IlinkIcfFile: dpp-qxk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; EFM32PG1B200F256GM48
  ICCARM.CCOptStrategy: 1
configuration Spy (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 4
  ICCARM.CCDefines: Q_SPY; EFM32PG1B200F256GM48
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  group Application
    ../: bsp.cpp main.cpp test.cpp test.hpp
    ../../: bsp.h dpp.h philo.cpp table.cpp
    ../../../../../include/: qstamp.cpp
  group efm32pg1b
    ../../../../../3rd_party/efm32pg1b/: em_cmu.c em_emu.c em_gpio.c em_usart.c system_efm32pg1b.c
    ../../../../../3rd_party/efm32pg1b/iar/: startup_efm32pg1b.s
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/: qf_pkg.h qxk_pkg.h
    ../../../../../src/qxk/: qxk.cpp qxk_mutex.cpp qxk_sema.cpp qxk_xthr.cpp
  group QP_port
    ../../../../../ports/arm-cm/qxk/iar/: qxk_port.cpp
  group QS
    ../../../../../src/qs/: qs.cpp qs_fp.cpp qs_rx.cpp
    ../../../../../src/: qs_pkg.h
