# IAR project dpp-ucos2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: EFM32PG1B200F256GM48; __TARGET_FPU_SOFTVFP
  ICCARM.CCDiagSuppress: Pe540
  ICCARM.IExtraOptions: --enable-restrict
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\ucos-ii; ..\..\..\..\..\3rd_party\ucos-ii\Source; ..\..\..\..\..\3rd_party\ucos-ii\Ports\ARM-Cortex-M\ARMv7-M\IAR; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\efm32pg1b
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-ucos2.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp-ucos2.out
  ILINK.IlinkIcfFile: dpp-ucos2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; EFM32PG1B200F256GM48
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\ucos-ii; ..\..\..\..\..\3rd_party\uCOS-II\Source; ..\..\..\..\..\3rd_party\uCOS-II\Ports\ARM-Cortex-M4\Generic\ARM; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\efm32pg1b
  ICCARM.CCOptStrategy: 1
configuration Spy (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 4
  ICCARM.CCDefines: Q_SPY; EFM32PG1B200F256GM48
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  group Application
    ../: app_cfg.h bsp.cpp dpp.h main.cpp os_cfg.h test.cpp test.h
    ../../: bsp.h dpp.h philo.cpp table.cpp
    ../../../../../include/: qstamp.cpp
  group efm32pg1b
    ../../../../../3rd_party/efm32pg1b/: em_cmu.c em_gpio.c em_usart.c system_efm32pg1b.c
    ../../../../../3rd_party/efm32pg1b/iar/: startup_efm32pg1b.s
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_defer.cpp qf_dyn.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/: qf_pkg.h
  group QP_port
    ../../../../../ports/ucos-ii/: app_cfg.h os_cfg.h qep_port.h qf_port.cpp qf_port.h qs_port.h
  group QS
    ../../../../../src/qs/: qs.cpp qs_fp.cpp qs_rx.cpp
    ../../../../../src/: qs_pkg.h
  group ucos-ii
    ../../../../../3rd_party/ucos-ii/Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group ucos-ii_port
    ../../../../../3rd_party/ucos-ii/Ports/ARM-Cortex-M/ARMv7-M/IAR/: os_cpu.h os_cpu_a.asm os_dbg.c
    ../../../../../3rd_party/ucos-ii/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
