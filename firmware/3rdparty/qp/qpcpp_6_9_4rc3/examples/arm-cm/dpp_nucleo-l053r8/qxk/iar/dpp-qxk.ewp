# IAR project dpp-qxk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: QXK_ON_CONTEXT_SW
  ICCARM.CCDiagSuppress: Pe540
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\arm-cm\qxk\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\nucleo-l053r8
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qxk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp-qxk.out
  ILINK.IlinkIcfFile: dpp-qxk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: Q_SPY; QXK_ON_CONTEXT_SW
  group Application
    ../: bsp.cpp main.cpp test.cpp
    ../../: philo.cpp table.cpp
    ../../../../../include/: qstamp.cpp
  group nucleo-l053r8
    ../../../../../3rd_party/nucleo-l053r8/iar/: startup_stm32l053xx.s
    ../../../../../3rd_party/nucleo-l053r8/: stm32l053xx.h stm32l0xx.h system_stm32l0xx.c system_stm32l0xx.h
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/: qf_pkg.h qxk_pkg.h
    ../../../../../src/qxk/: qxk.cpp qxk_mutex.cpp qxk_sema.cpp qxk_xthr.cpp
  group QP_port
    ../../../../../ports/arm-cm/qxk/iar/: qep_port.h qf_port.h qs_port.h qxk_port.cpp qxk_port.h
  group QS
    ../../../../../src/qs/: qs.cpp qs_fp.cpp qs_rx.cpp
