# IAR project dpp-qxk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H743xx; QXK_ON_CONTEXT_SW; USE_HAL_DRIVER; USE_STM32H7XX_NUCLEO_144
  ICCARM.CCDiagSuppress: Pe540
  ICCARM.IExtraOptions: --enable-restrict
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\arm-cm\qxk\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\nucleo-h743zi; ..\..\..\..\..\3rd_party\nucleo-h743zi\Drivers\BSP\STM32H7xx_Nucleo_144; ..\..\..\..\..\3rd_party\nucleo-h743zi\Drivers\STM32H7xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qxk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp-qxk.out
  ILINK.IlinkIcfFile: dpp-qxk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32H743xx; USE_HAL_DRIVER; USE_STM32H7XX_NUCLEO_144
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; QXK_ON_CONTEXT_SW; STM32H743xx; USE_HAL_DRIVER; USE_STM32H7XX_NUCLEO_144
  group Application
    ../: bsp.cpp main.cpp test.cpp
    ../../: bsp.h dpp.h philo.cpp table.cpp
    ../../../../../include/: qstamp.cpp
  group nucleo-h743zi
    ../../../../../3rd_party/nucleo-h743zi/iar/: startup_stm32h743xx.s
    ../../../../../3rd_party/nucleo-h743zi/: stm32h743xx.h stm32h7xx.h system_stm32h7xx.c system_stm32h7xx.h
    ../../: stm32h7xx_hal_conf.h stm32h7xx_hal_msp.c
    ../../../../../3rd_party/nucleo-h743zi/Drivers/BSP/STM32H7xx_Nucleo_144/: stm32h7xx_nucleo_144.c stm32h7xx_nucleo_144.h
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../../../src/qxk/: qxk.cpp qxk_mutex.cpp qxk_sema.cpp qxk_xthr.cpp
  group QP_port
    ../../../../../ports/arm-cm/qxk/iar/: qep_port.h qf_port.h qs_port.h qxk_port.cpp qxk_port.h
  group QS
    ../../../../../src/qs/: qs.cpp qs_fp.cpp qs_rx.cpp
  group STM32H7xx_HAL_Driver
    ../../../../../3rd_party/nucleo-h743zi/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c
