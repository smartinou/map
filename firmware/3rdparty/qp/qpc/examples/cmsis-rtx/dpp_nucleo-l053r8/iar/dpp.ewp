# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053x8 ST STM32L053x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..\include; ..\..\..\..\source; ..\..\..\..\ports\cmsis-rtx; ..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\3rd_party\CMSIS-RTX\INC; ..\..\..\..\3rd_party\nucleo-l053r8
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkIcfFile: dpp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY
  group Application
    ../: bsp.c bsp.h dpp.h gpio.h main.c philo.c rom.h RTX_Conf_CM.c table.c
    ../../../../include/: qstamp.c
  group CMSIS-RTX
    ../../../../3rd_party/CMSIS-RTX/LIB/IAR/: RTX_CM0.a
  group nucleo-l053r8
    ../../../../3rd_party/nucleo-l053r8/iar/: startup_stm32l053xx.s
    ../../../../3rd_party/nucleo-l053r8/: stm32l053xx.h stm32l0xx.h system_stm32l0xx.c system_stm32l0xx.h
  group QP
    ../../../../source/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_pkg.h qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
  group QP_port
    ../../../../ports/cmsis-rtx/: qep_port.h qf_port.c qf_port.h qs_port.h
  group QS
    ../../../../source/: qs.c qs_64bit.c qs_fp.c qs_pkg.h
