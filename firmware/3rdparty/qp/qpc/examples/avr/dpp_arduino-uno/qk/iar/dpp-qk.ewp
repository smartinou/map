# IAR project dpp-qk.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 256
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m328p ATmega328P
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: .; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\source; ..\..\..\..\..\ports\avr\qk\iar
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 2
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm328p.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x100
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
configuration Spy (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x100
  ICCAVR.CCDefines: Q_SPY
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm169.xcl
  group Application
    ./: bsp.c
    ../../: bsp.h dpp.h main.c philo.c table.c
    ../../../../../include/: qstamp.c
  group QP
    ../../../../../source/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_pkg.h qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c qk.c qk_mutex.c qk_pkg.h
  group QP_port
    ../../../../../ports/avr/qk/iar/: qep_port.h qf_port.h qk_port.c qk_port.h qs_port.h
  group QS
    ../../../../../source/: qs.c qs_64bit.c qs_fp.c qs_pkg.h qs_rx.c
