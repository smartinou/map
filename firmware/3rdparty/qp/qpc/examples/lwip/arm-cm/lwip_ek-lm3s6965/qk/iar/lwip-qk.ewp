# IAR project lwip-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\..\include; ..\..\..\..\..\..\source; ..\..\..\..\..\..\ports\arm-cm\qk\iar; ..\..\..\..\..\..\3rd_party\ek-lm3s6965; ..\..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\..\3rd_party\ek-lm3s6965\lwip_driver; ..\..\..\..\..\..\3rd_party\lwip\src\include; ..\..\..\..\..\..\3rd_party\lwip\src\include\ipv4; ..\..\..\..\..\..\3rd_party\lwip\src; ..\..\..\..\..\..\3rd_party\lwip\apps\webserver_raw
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: lwip-qk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: lwip-qk.out
  ILINK.IlinkIcfFile: lwip-qk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY
  group application
    ../: bsp.c
    ../../: bsp.h dpp.h fsdata.h lwip.c lwip.h lwipmgr.c lwipopts.h main.c philo.c table.c
    ../../../../../../include/: qstamp.c
  group ek-lm3s6965
    ../../../../../../3rd_party/ek-lm3s6965/lwip_driver/netif/: eth_driver.c eth_driver.h
    ../../../../../../3rd_party/ek-lm3s6965/: LM3S6965.h rit128x96x4.c rit128x96x4.h system_LM3S6965.c system_LM3S6965.h
    ../../../../../../3rd_party/ek-lm3s6965/iar/: startup_LM3S6965.s
  group QP
    ../../../../../../source/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_pkg.h qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c qk.c qk_mutex.c qk_pkg.h
  group QP_port
    ../../../../../../ports/arm-cm/qk/iar/: qep_port.h qf_port.h qk_port.h qk_port.s qs_port.h
  group QS
    ../../../../../../source/: qs.c qs_64bit.c qs_fp.c qs_pkg.h
  group webserver_raw
    ../../../../../../3rd_party/lwip/apps/webserver_raw/: fs.c fs.h httpd.c httpd.h
