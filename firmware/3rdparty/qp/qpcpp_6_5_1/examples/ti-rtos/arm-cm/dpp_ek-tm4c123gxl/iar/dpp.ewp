# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.IExtraOptions: --enable-restrict; -f; configPkg/compiler.opt.defs; --diag_suppress=Pa050; -I$TIVAWARE$; -I$BIOS$/ti/sysbios/posix; -DPART_TM4C123GH6PM; -Dewarm; -DTIVAWARE; --debug; --silent
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\ti-rtos
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $PROJ_FNAME$_EK_TM4C123GXL.icf
  ILINK.IlinkExtraOptions: -f; configPkg/linker.cmd; $TIVAWARE$/grlib/ewarm/Exe/grlib.a; $TIVAWARE$/usblib/ewarm/Exe/usblib.a; $TIVAWARE$/driverlib/ewarm/Exe/driverlib.a; --silent; --cpu=Cortex-M4F; --entry=__iar_program_start; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ./: Board.h dpp.cfg dpp_EK_TM4C123GXL.icf EK_TM4C123GXL.h
    ../: Board.h bsp.cpp bsp.h dpp.h EK_TM4C123GXL.c EK_TM4C123GXL.h main.cpp philo.cpp table.cpp
  group QP
    ../../../../../src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_pkg.h qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
  group QP_port
    ../../../../../ports/ti-rtos/: qep_port.h qf_port.cpp qf_port.h qs_port.h
